FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://qemu.cfg"
