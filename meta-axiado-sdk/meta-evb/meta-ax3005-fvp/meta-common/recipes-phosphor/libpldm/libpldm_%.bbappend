PACKAGECONFIG = "abi-development"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

