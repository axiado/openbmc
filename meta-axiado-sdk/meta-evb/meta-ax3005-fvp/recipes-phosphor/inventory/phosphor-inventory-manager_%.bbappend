DEPENDS:append = " inventory-cleanup"

