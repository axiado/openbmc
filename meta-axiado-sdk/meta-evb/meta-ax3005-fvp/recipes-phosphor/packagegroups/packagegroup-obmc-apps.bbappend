RDEPENDS:${PN}-extras:append = " \
  pldm \
  mctp \
  bmcweb \
  webui-vue \
  phosphor-host-postd \
  phosphor-post-code-manager \
  phosphor-misc-usb-ctrl  \
  usb-network \
  smbios-mdr \
  phosphor-ipmi-blobs \
  biosconfig-manager \
  phosphor-state-manager \
"
