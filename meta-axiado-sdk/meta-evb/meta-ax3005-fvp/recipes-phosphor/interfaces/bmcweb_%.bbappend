PACKAGECONFIG:append = " \
    redfish-dump-log \
"

EXTRA_OEMESON = " \
  -Dhttp2=disabled \
"

