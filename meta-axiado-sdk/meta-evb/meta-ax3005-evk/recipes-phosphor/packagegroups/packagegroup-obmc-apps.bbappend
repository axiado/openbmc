RDEPENDS:${PN}-extras += "optee-examples optee-test"
