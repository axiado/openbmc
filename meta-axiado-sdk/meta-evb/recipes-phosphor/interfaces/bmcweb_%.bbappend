EXTRA_OEMESON += "-Dhttp-body-limit=65"
PACKAGECONFIG += "redfish-dump-log"
