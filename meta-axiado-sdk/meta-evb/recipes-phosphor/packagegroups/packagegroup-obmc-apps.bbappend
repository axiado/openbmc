RDEPENDS:${PN}-extras:append = " curl"
RDEPENDS:${PN}-extras:append = " entity-manager"
RDEPENDS:${PN}-ikvm = ""
