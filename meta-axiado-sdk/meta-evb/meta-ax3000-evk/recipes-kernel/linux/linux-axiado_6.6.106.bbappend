FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://dc-scm.cfg \
            file://dc-scm.scc \
            file://usb-storage.cfg \
            file://usb-storage.scc \
            "
