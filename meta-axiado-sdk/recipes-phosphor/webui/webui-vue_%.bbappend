# Downgrade to use Vue-CLI instead of Vite
SRCREV = "313d15cf9f14e8a264f97a3370c3be4e494e5e0d"
