RDEPENDS:${PN}-network:append = " ax-net iptables iproute2 net-tools"
RDEPENDS:${PN}-extras:append = " gptfdisk parted"
RDEPENDS:${PN}-extras:append = " axiado-eip-firmware boot-state logmgr tcu-reset"
