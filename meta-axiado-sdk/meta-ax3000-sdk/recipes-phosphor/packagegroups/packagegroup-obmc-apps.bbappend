RDEPENDS:${PN}-extras += "sysproxy tdfu"
