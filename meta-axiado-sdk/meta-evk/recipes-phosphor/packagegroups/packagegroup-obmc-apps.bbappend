RDEPENDS:${PN}-extras += "curl"
RDEPENDS:${PN}-extras:append:evk-axiado-github = " eipdrv-axiado shimfwl-axiado"
