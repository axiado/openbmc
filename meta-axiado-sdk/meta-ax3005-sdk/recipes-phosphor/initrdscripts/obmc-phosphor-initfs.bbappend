FILESEXTRAPATHS:append := "${THISDIR}/files:"

RDEPENDS:${PN}:append = " axiado-eip-firmware"
