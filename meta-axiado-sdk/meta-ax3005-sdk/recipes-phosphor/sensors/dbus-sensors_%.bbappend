FILESEXTRAPATHS:append := ":${THISDIR}/files"

SRC_URI += "file://0001-Add-new-MCTPMailboxTarget-type-into-MCTPReactor.patch"
