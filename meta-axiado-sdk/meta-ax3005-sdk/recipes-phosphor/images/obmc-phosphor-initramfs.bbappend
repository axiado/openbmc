INIT_PACKAGE = "phosphor-mmc-init"
