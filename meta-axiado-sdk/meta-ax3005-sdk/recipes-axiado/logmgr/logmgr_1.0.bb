require recipes-axiado/logmgr/logmgr.inc

PV = "1.0+dev"

SRCBRANCH = "release/release-u-0.2.0"
SRCREV = "278295f2cdb939205010226e4586519ba57720d5"
SRC_URI = "git://bitbucket.org/ax-engg/logmgr.git;protocol=https;branch=${SRCBRANCH}"
