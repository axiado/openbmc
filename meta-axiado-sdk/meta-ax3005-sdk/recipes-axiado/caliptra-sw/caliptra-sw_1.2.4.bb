require caliptra-sw.inc

PV = "1.2.4+dev"
