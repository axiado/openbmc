require caliptra-sw.inc

SRCBRANCH = "develop"
SRCREV = "15512531781016c126dcb9ee6963410b6a9200b0"
SRC_URI = "gitsm://github.com/axiado/caliptra-sw;protocol=https;branch=${SRCBRANCH}"

PV = "1.2.4+git"
