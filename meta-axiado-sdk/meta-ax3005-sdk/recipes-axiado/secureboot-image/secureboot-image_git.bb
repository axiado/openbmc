require secureboot-image.inc

PV = "1.0+git"
